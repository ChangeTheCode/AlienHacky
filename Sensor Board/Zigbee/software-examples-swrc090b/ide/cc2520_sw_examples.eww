<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520\iar\ccm_security.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520_91\iar\ccm_security.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520\iar\hello.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520\iar\light_switch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520_91\iar\light_switch.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520\iar\per_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520_91\iar\per_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520\iar\reg_read.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520\iar\spectrum_analyzer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\srf05_ccmsp2618_cc2520_91\iar\spectrum_analyzer.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>ccm_security</project>
        <configuration>srf05_ccmsp2618_cc2520</configuration>
      </member>
      <member>
        <project>ccm_security</project>
        <configuration>srf05_ccmsp2618_cc2520_91</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>srf05_ccmsp2618_cc2520</configuration>
      </member>
      <member>
        <project>light_switch</project>
        <configuration>srf05_ccmsp2618_cc2520</configuration>
      </member>
      <member>
        <project>light_switch</project>
        <configuration>srf05_ccmsp2618_cc2520_91</configuration>
      </member>
      <member>
        <project>per_test</project>
        <configuration>srf05_ccmsp2618_cc2520</configuration>
      </member>
      <member>
        <project>per_test</project>
        <configuration>srf05_ccmsp2618_cc2520_91</configuration>
      </member>
      <member>
        <project>reg_read</project>
        <configuration>srf05_ccmsp2618_cc2520</configuration>
      </member>
      <member>
        <project>spectrum_analyzer</project>
        <configuration>srf05_ccmsp2618_cc2520</configuration>
      </member>
      <member>
        <project>spectrum_analyzer</project>
        <configuration>srf05_ccmsp2618_cc2520_91</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


