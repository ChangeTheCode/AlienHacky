# IAR project spectrum_analyzer.ewp, settings and files
configuration srf05_ccmsp2618_cc2520_91 (MSP430, debug)
  General.OGChipSelectMenu: MSP430F2618 MSP430F2618
  General.GStackSize2: 256
  General.GHeapSize2: 80
  ICC430.CCDefines: ASSY_CCMSP2618_CC2520; INCLUDE_PA=2591
  ICC430.CCDiagSuppress: Pe001,Pe177,Pa084
  ICC430.newCCIncludePaths: ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common/msp430; ../../../source/Components/targets/srf05_ccmsp2618; ../../../source/Components/radios/cc2520
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2618.xcl
  XLINK.XlinkStackSize: 1
  group application
    ../../../source/apps/spectrum_analyzer/: spectrum_analyzer.c
  group utilities
    ../../../source/Components/utils/: util_lcd.c util_lcd.h util.c util.h util_menu.h
  group hal/common
    ../../../source/Components/common/: hal_int.c hal_defs.h hal_types.h
    ../../../source/Components/common/msp430/: hal_msp430.h
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_led.h hal_lcd.h hal_mcu.h
  group hal/rf
    ../../../source/Components/targets/interface/: hal_rf.h hal_rf_util.h
  group hal/rf/cc2520
    ../../../source/Components/radios/cc2520/: hal_cc2520.c hal_cc2520.h hal_rf.c hal_rf_util.c
  group hal/ccmsp2618
    ../../../source/Components/targets/srf05_ccmsp2618/: hal_assert.c hal_board.c hal_board.h hal_digio.c hal_joystick.c hal_lcd.c hal_led.c hal_mcu.c hal_button.c
  group hal/cc2520em
    ../../../source/Components/assembly/: assy_ccmsp2618_cc2520em.c assy_ccmsp2618_cc2520em.h
